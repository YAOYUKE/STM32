# Keil uVision project Project.uvprojx, settings and files
target Project (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103R6 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x2800) IROM(0x08000000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_LD,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\STM32F10x_FWLIB\inc;..\USER;..\HARDWARE\LED;..\SYSTEM\delay;..\HARDWARE\BEEP
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group README
    ../: Readme.txt
  group CORE
    ../CORE/: startup_stm32f10x_ld.s core_cm3.c
  group FWLIB
    ../STM32F10x_FWLIB/src/: stm32f10x_gpio.c stm32f10x_rcc.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/BEEP/: beep.c
  group SYSTEM
    ../SYSTEM/DELAY/: delay.c
  group USER
    ./: main.c system_stm32f10x.c stm32f10x_it.c
